# Keil uVision project Teste.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Teste
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LibCMSIS;.\LibFreeRTOS;..\Projeto_Teste;.\LibNetwork
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c system_LPC17xx.c
    ./LibFreeRTOS/: FreeRTOS.lib startup_MPS_CM3.s
    ./LibCMSIS/: CMSIS.lib
    ./LibNetwork/: Network.lib
